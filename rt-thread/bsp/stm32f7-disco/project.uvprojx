# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f7xx (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rtthread-stm32f7xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32F746xx
  c include: .\Libraries\STM32F7xx_HAL_Driver\Inc;../../components/CMSIS/RTOS;../../components/drivers/include;../../components/drivers/spi;../../components/finsh;../../components/libc/armlibc;../../components/pthreads;../../include;../../libcpu/arm/common;../../libcpu/arm/cortex-m7;Libraries/CMSIS/Device/ST/STM32F7xx/Include;Libraries/CMSIS/Include;Libraries/STM32F7xx_HAL_Driver/Inc;MotorFLOATLIB;MotorFLOATLIB/inc;SAEJ1939;applications;drivers;..\stm32f7-disco
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group MOTORFLOATLIB
    MotorFLOATLIB/modules/Han_Endat/: Han_Endat.c
    MotorFLOATLIB/modules/InitPosDet/: InitPosDet.c
    MotorFLOATLIB/modules/MotorCtrlApp/: MotorCtrlApp.c
    MotorFLOATLIB/modules/Speed/: Speed.c
    MotorFLOATLIB/modules/clarke/: clarke.c
    MotorFLOATLIB/modules/ctrl/: ctrl.c
    MotorFLOATLIB/modules/data_rtxd/: data_rtxd.c
    MotorFLOATLIB/modules/data_select/: data_select.c
    MotorFLOATLIB/modules/est/: est.c
    MotorFLOATLIB/modules/filter/: filter_fo.c filter_so.c
    MotorFLOATLIB/modules/hal/: hal.c
    MotorFLOATLIB/modules/ipark/: ipark.c
    MotorFLOATLIB/modules/offset/: offset.c
    MotorFLOATLIB/modules/park/: park.c
    MotorFLOATLIB/modules/pid/: pid.c
    MotorFLOATLIB/modules/rampgen/: rampgen.c
    MotorFLOATLIB/modules/rmp_cntl/: rmp_cntl.c
    MotorFLOATLIB/modules/svgen/: svgen.c
    MotorFLOATLIB/modules/traj/: traj.c
    MotorFLOATLIB/modules/user/: user.c
  group STM32F7xx_HAL_Driver
    Libraries/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group CMSIS
    Libraries/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
    Libraries/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f746xx.s
  group J1939
    SAEJ1939/: SAEJ1939_21.c SAEJ1939_81.c SAEJ1939_lowlevel.c
  group Drivers
    drivers/: Drv_Can.c board.c drv_ADCV0.c drv_ADCV1.c drv_MisoMotor.c drv_QEP.c drv_mpu.c drv_sdram.c drv_tim8.c drv_touch.c drv_usart.c ft5336.c sdio_sd.c stm32746g_discovery.c stm32746g_discovery_ts.c stm32f7xx_eth.c stm32f7xx_it.c
  group Applications
    applications/: CanTask.c FramewinDLG_graph.c Http_server.c MotorTaskV0.c MotorTaskV1.c UserGUI.c WIDGET_GraphYT.c application.c http.c k_bsp.c k_menu.c k_startup.c sram.c startup.c uart3task.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M7
    ../../libcpu/arm/cortex-m7/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group pthreads
    ../../components/pthreads/: clock_time.c mqueue.c pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c semaphore.c
  group libc
    ../../components/libc/armlibc/: mem_std.c stubs.c
  group CMSIS_OS
    ../../components/CMSIS/RTOS/: cmsis_rtthread.c
  group DeviceDrivers
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../components/drivers/mtd/: mtd_nand.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/can/: can.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh_cmd.c msh.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
